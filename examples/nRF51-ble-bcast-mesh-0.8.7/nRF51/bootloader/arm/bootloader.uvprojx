# Keil uVision project bootloader.uvprojx, settings and files
target nRF51422 xxAC serial (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader_serial_xxAC +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: NRF51 BOARD_PCA10028 BOOTLOADER RBC_MESH_SERIAL RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1 uECC_PLATFORM=uECC_arm
  c misc: --c99 --debug
  c include: ..\..\rbc_mesh\include;..\..\RTT;..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\components\toolchain\gcc;..\..\..\..\SDK\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\rbc_mesh;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\include;..\..\..\..\..\components\device;..\..\..\..\..\components\libraries\sha256;..\..\SDK\bsp;..\core\include
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
  link misc: --diag-suppress 6314
  group app
    ../: main.c transport.c bootloader_rtc.c bootloader.c
  group core
    ./: system_nrf52.c arm_startup_nrf52.s system_nrf51.c arm_startup_nrf51.s
  group lib
    ../../../../../components/libraries/sha256/: sha256.c
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group rbc_mesh
    ../../rbc_mesh/src/: rand.c fifo.c mesh_aci.c mesh_packet.c nrf_flash.c radio_control.c serial_handler_uart.c bootloader_util.c
  group shared
    ../core/: bootloader_app_bridge.c bootloader_info.c uECC.c dfu_mesh.c dfu_transfer_mesh.c dfu_bank.c
    ../../rbc_mesh/src/: dfu_util.c
target nRF51422 xxAC serial debug (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: bootloader_serial_debug_xxAC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RTT_LOG DEBUG NRF51 BOARD_PCA10028 BOOTLOADER RBC_MESH_SERIAL RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1 uECC_PLATFORM=uECC_arm
  c misc: --c99 --debug
  c include: ..\..\rbc_mesh\include;..\..\RTT;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\toolchain\gcc;..\..\..\..\SDK\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\rbc_mesh;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\include;..\..\..\..\..\components\device;..\..\..\..\..\components\libraries\sha256;..\..\SDK\bsp;..\core\include
  library: MicroLIB
  memory RVCT4: ROM 0x36000 size 0x9800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader_xxAC +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: NRF51 BOARD_PCA10028 BOOTLOADER RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1
  c misc: --c99 --debug
  c include: ..\..\rbc_mesh\include;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\toolchain\gcc;..\..\..\..\SDK\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\rbc_mesh;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\include;..\..\..\..\..\components\device;..\..\..\..\..\components\libraries\sha256;..\..\SDK\bsp;..\core\include;..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x7cfc
  memory RVCT10: RAM 0x20007d00 size 0x2fc
target nRF51422 xxAA serial (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: bootloader_serial_xxAA +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: bootloader_xxAA +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
target nRF51422 xxAB serial (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader_serial_xxAB +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
  link misc: --diag-suppress 6314
target nRF51422 xxAB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: bootloader_xxAB +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: as above
  c misc: --c99 --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1a000 size 0x5800
  memory RVCT9: RAM 0x20000004 size 0x3cfc
  memory RVCT10: RAM 0x20003d00 size 0x2fc
target nRF52832 xxAA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: bootloader_serial_xxAA +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: NORDIC_SDK_VERSION=12 NRF52 BOARD_PCA10040 BOOTLOADER RBC_MESH_SERIAL RBC_MESH_PACKET_POOL_SIZE=32 uECC_CURVE=uECC_secp256r1 uECC_PLATFORM=uECC_arm
  c misc: --c99 --debug
  c include: ..\..\rbc_mesh\include;..\..\RTT;..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\SDK\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\rbc_mesh;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\fifo;..\include;..\..\..\..\..\components\device;..\..\..\..\..\components\libraries\sha256;..\..\SDK\bsp;..\core\include;..\..\..\..\..\components\toolchain\cmsis\include;..\..\..\..\..\components\softdevice\s132\headers\nrf52
  library: MicroLIB
  memory RVCT4: ROM 0x78000 size 0x6000
  memory RVCT9: RAM 0x20000004 size 0x8ffc
  memory RVCT10: RAM 0x20009000 size 0xffc
